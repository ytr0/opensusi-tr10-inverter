v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {ytr0_top (sram_only)} -300 -200 0 0 0.4 0.4 {}
C {../../ytr0_sram.sym} 0 0 0 0 {name=X1}
C {devices/lab_pin.sym} 150 -30 0 0 {name=pDATA sig_type=std_logic lab=DATA}
C {devices/lab_pin.sym} 150 -10 0 0 {name=pWORD sig_type=std_logic lab=WORD}
C {devices/lab_pin.sym} 150 10 0 0 {name=pVDD sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 150 30 0 0 {name=pVSS sig_type=std_logic lab=VSS}
C {devices/iopin.sym} -300 -300 0 0 {name=P_DATA lab=DATA}
C {devices/iopin.sym} -300 -270 0 0 {name=P_WORD lab=WORD}
C {devices/iopin.sym} -300 -240 0 0 {name=P_VDD lab=VDD}
C {devices/iopin.sym} -300 -210 0 0 {name=P_VSS lab=VSS}
